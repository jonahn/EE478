# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F4XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Project\; ..\Utilities\STM32F4-Discovery; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\CMSIS\Include; ..\Libraries\CMSIS\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c
  group STM32F4_Discovery
    ../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio_codec.c stm32f4_discovery_lis302dl.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/CMSIS/ST/STM32F4xx/Include/: stm32f4xx.h
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_adc.h
    ./: stm32f4xx_conf.h
  group user
    ./: main.c setupSDIO.c
